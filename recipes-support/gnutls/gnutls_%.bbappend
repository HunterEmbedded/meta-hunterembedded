EXTRA_OECONF = " HOGWEED_LIBS=-lhogweed"