require recipes-core/images/core-image-minimal.bb

DESCRIPTION = "Optimized image for Pi-Hole"

require pi-hole-packages.inc

